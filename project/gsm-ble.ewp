# IAR project gsm-ble.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52832-xxAA NordicSemi nRF52832-xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: S132; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=5
  ICCARM.CCIncludePath2: ..\sources; ..\libraries\s132_nrf52_5.0.0_API\include; ..\libraries\s132_nrf52_5.0.0_API\include\nrf52; ..\libraries\device\; ..\libraries\timer\; ..\libraries\util\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gsm-ble.srec
  ILINK.IlinkOutputFile: gw-nrf.out
  ILINK.IlinkIcfFile: nRF52832s132.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group libraries/device
    ../libraries/device/: compiler_abstraction.h nrf.h nrf51.h nrf51422_peripherals.h nrf51802_peripherals.h nrf51822_peripherals.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf51_to_nrf52810.h nrf51_to_nrf52840.h nrf52.h nrf52810.h nrf52810_bitfields.h nrf52810_peripherals.h nrf52832_peripherals.h nrf52840.h nrf52840_bitfields.h nrf52840_peripherals.h nrf52_bitfields.h nrf52_name_change.h nrf52_to_nrf52810.h nrf52_to_nrf52840.h
  group libraries/s132_nrf52_5.0.0_API/include
    ../libraries/s132_nrf52_5.0.0_API/include/: ble.h ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sdm.h nrf_soc.h nrf_svc.h
  group libraries/s132_nrf52_5.0.0_API/include/nrf51
    ../libraries/s132_nrf52_5.0.0_API/include/nrf52/: nrf_mbr.h
  group libraries/timer
    ../libraries/timer/: app_timer.c app_timer.h
  group libraries/util
    ../libraries/util/: app_error.c app_error.h app_error_weak.c app_error_weak.h app_util.h app_util_bds.h app_util_platform.c app_util_platform.h nordic_common.h nrf_assert.c nrf_assert.h nrf_bitmask.h sdk_common.h sdk_errors.h sdk_macros.h sdk_mapped_flags.c sdk_mapped_flags.h sdk_os.h sdk_resources.h
  group sources
    ../sources/: advertizer.c advertizer.h central.c central.h iar_startup_nrf52.s led.c led.h main.c modem.c modem.h nrf_delay.h sdk_config.h sensors.c sensors.h system_nrf52.c system_nrf52.h uart.c uart.h
